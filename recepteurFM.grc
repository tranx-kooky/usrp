options:
  parameters:
    author: operateur
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: recepteurFM
    output_language: python
    title: recepteur FM
  states: {}

blocks:
- name: cutoff
  id: variable_qtgui_range
  parameters:
    start: 10e3
    step: 5e3
    stop: 100e3
    value: 100e3
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 87.9*10**6
    step: 200*10**3
    stop: 107.9*10**6
    value: 89.9*10**6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: serial
  id: variable
  parameters:
    value: '"\"serial=322F67E\""'
  states: {}
- name: serial
  id: variable
  parameters:
    value: '"\"serial=31E749F\""'
  states: {state: disabled}
- name: serial
  id: variable
  parameters:
    value: '"serial=31E9F6C"'
  states: {state: disabled}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    deemph_tau: '75e-6'
    quad_rate: '192000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: '1'
    gain: '40'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: cutoff/5
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"avant filtrage"'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"apres filtrage"'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '125'
    interp: '24'
    type: ccc
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq
    dev_addr: serial
    rx_agc0: Enabled
    samp_rate: samp_rate
    sync: pc_clock_next_pps
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-1029-g3c48f5e2
